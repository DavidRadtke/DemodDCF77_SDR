<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>96000</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>0.006</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0.003</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/radtke/Schreibtisch/WebSDRDateien/websdr_11_07_17_11.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.basic_block):  # basic Block -&gt; input ungleich output


    def __init__(self, SampleDelay=1000):  
        """arguments to this function show up as parameters in GRC"""
        gr.basic_block.__init__(
            self,
            name='DCF77 Demodulator',   
            in_sig=[np.float32],
            out_sig=[np.float32],
        )


        self.SampleDelay = SampleDelay
	self.set_history(2)
	self.state=0
	self.counter=0		
	self.Bitcounter = -1   # -1, da erst bei Start einer Minute wieder 0, Zeigt aktuelles Bit
	self.Jahr = 0
	self.Monat = 0
	self.Wochentag = 0
	self.Kalendertag = 0
	self.Stunde = 0
	self.Minute = 0
	self.day = 0
    def general_work(self, input_items, output_items):
        """example: multiply with constant"""

	in0=input_items[0]
	out0=output_items[0]
	outcounter=0
	for k in range(1,len(in0)):
	
	
		if (in0[k] - in0[k-1] &lt; 0):  				#Fallende Flanke erkannt?
			
			
			self.state=1					#state = 1, Fallende Flanke erkannt
			self.counter=self.SampleDelay			#Counter starten

		if self.state==1 and self.counter == 0:			#Status nach fallender Flanke
			
			if self.Bitcounter == 59:			#Bitcounter zurcksetzen
				self.Bitcounter = 0
			
			self.state=0

			#Logische 1 von DCF77, Start erst wenn Minute erkannt wurde (Bitcounter &gt;= 0)
			if in0[k] == 0 and self.Bitcounter &gt;= 0:   	
				
				# Beginn Zuweisung/Errechnen des Datums/Uhrzeit							
				if self.Bitcounter == 54:		
					self.Jahr = self.Jahr + 10 
				if self.Bitcounter == 53:
					self.Jahr = self.Jahr + 8	
				if self.Bitcounter == 52:
					self.Jahr = self.Jahr + 4
				if self.Bitcounter == 51:
					self.Jahr = self.Jahr + 2
				if self.Bitcounter == 50:
					self.Jahr = self.Jahr + 1
				if self.Bitcounter == 49:
					self.Monat = self.Monat + 10
				if self.Bitcounter == 48:
					self.Monat = self.Monat + 8
				if self.Bitcounter == 47:
					self.Monat = self.Monat + 4
				if self.Bitcounter == 46:
					self.Monat = self.Monat + 2
				if self.Bitcounter == 45:
					self.Monat = self.Monat + 1
				if self.Bitcounter == 44:
					self.Wochentag = self.Wochentag + 4
				if self.Bitcounter == 43:
					self.Wochentag = self.Wochentag + 2
				if self.Bitcounter == 42:
					self.Wochentag = self.Wochentag + 1
				if self.Bitcounter == 41:
					self.Kalendertag = self.Kalendertag + 20
 				if self.Bitcounter == 40:
					self.Kalendertag = self.Kalendertag + 10
 				if self.Bitcounter == 39:
					self.Kalendertag = self.Kalendertag + 8
 				if self.Bitcounter == 38:
					self.Kalendertag = self.Kalendertag + 4
				if self.Bitcounter == 37:
					self.Kalendertag = self.Kalendertag + 2
				if self.Bitcounter == 36:
					self.Kalendertag = self.Kalendertag + 1
				if self.Bitcounter == 34:
					self.Stunde = self.Stunde + 20
 				if self.Bitcounter == 33:
					self.Stunde = self.Stunde + 10
 				if self.Bitcounter == 32:
					self.Stunde = self.Stunde + 8
 				if self.Bitcounter == 31:
					self.Stunde = self.Stunde + 4
 				if self.Bitcounter == 30:
					self.Stunde = self.Stunde + 2
 				if self.Bitcounter == 29:
					self.Stunde = self.Stunde + 1
				if self.Bitcounter == 27:
					self.Minute = self.Minute + 40
 				if self.Bitcounter == 26:
					self.Minute = self.Minute + 20
				if self.Bitcounter == 25:
					self.Minute = self.Minute + 10			
				if self.Bitcounter == 24:
					self.Minute = self.Minute + 8
				if self.Bitcounter == 23:
					self.Minute = self.Minute + 4
				if self.Bitcounter == 22:
					self.Minute = self.Minute + 2
				if self.Bitcounter == 21:
					self.Minute = self.Minute + 1

  
 
				self.Bitcounter = self.Bitcounter + 1
				
				out0[outcounter] = 1

			if in0[k] == 1:		# logische 0 -&gt; DCF77
				
				out0[outcounter] = 0
				self.Bitcounter = self.Bitcounter + 1
			outcounter=outcounter+1

		if self.state==0 and self.counter &lt; -7400:  # Erstes Bit erkannt (Keine Absenkung auf 15% der Amplitude)
			
			print("Start/Stop")			
			self.counter=0
			out0[outcounter]=-1
			outcounter=outcounter+1
			self.Bitcounter = 0         # Erstes Bit

		self.counter=self.counter-1

 	self.consume(0,len(in0))
	if self.Wochentag == 1:
		self.day = 'Montag'	
	elif self.Wochentag == 2:
		self.day = 'Dienstag'
	elif self.Wochentag == 3:
		self.day = 'Mittwoch'
	elif self.Wochentag == 4:
		self.day = 'Donnerstag'
	elif self.Wochentag == 5:
		self.day = 'Freitag'
	elif self.Wochentag == 6:
		self.day = 'Samstag'
	elif self.Wochentag == 7:
		self.day = 'Sonntag'


	if self.Bitcounter == 59:		#Uhrzeit ausgeben 
		print("Zeit/Datum:  "  
  	       	 + '%0.2d' %(self.Stunde) + ":" + '%0.2d' %(self.Minute) + ",  " + str(self.day) + " der " +   
	   	'%0.2d' %(self.Kalendertag) + "." + '%0.2d' %(self.Monat) + "." + str(self.Jahr) )

		
		self.Bitcounter == -1		# Letztes Bit erreicht
	
	return outcounter
	
    

    def forecast(self, noutput_items, ninput_items_required):
        """
       forecast is only called from a general block
       this is the default implementation
       """
        ninput_items_required[0] = noutput_items	
	return
 
 
        return
</value></param>
<param><key>SampleDelay</key><value>1000</value></param>
</block>
<block>
<key>hilbert_fc</key>
<param><key>id</key><value>hilbert_fc_0</value></param>
<param><key>num_taps</key><value>65</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>samp_rate</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>hilbert_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hilbert_fc_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
